options:
  parameters:
    generate_options: qt_gui
    id: max2771_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      sudo mkfifo /tmp/ch12
      sudo app/pocket_dump/pocket_dump -r /tmp/ch12
      sign-magnitude format
      00->1
      01->3
      10 ->-1
      11 -> -3
    file: /tmp/ch12
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/jmfriedt/sdr/max2771/PocketSDR/r1
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    comment: 4 bit CH1 -- 4 bit CH2
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      RAW8PACKED: I0 I1 Q0 Q1  I0' I1' Q0' Q1'
      2-bit sign-magnitude
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1+1j*1, 3+1j*1, -1+1j, -3+1j*1,          1+1j*3, 3+1j*3, -1+1j*3, -3+1j*3,          1-1j*1, 3-1j*1, -1-1j,-3-1j*1,          1-1j*3, 3-1j*3, -1-1j*3, -3-1j*3]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: CH1
    label2: CH2
    nconnections: '2'
    type: complex
    ymax: '0'
    ymin: '-40'
  states: {}

connections:
- [blocks_deinterleave_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_deinterleave_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_file_source_1, '0', blocks_throttle2_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
