options:
  parameters:
    generate_options: no_gui
    id: max2771_2
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_1
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/chaoutc.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/chboutc.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/chbout.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/chaout.bin
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*8)
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    comment: 4 bit CH1 -- 4 bit CH2
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      RAW8PACKED: I0 I1 Q0 Q1  I0' I1' Q0' Q1'
      2-bit sign-magnitude
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1-1j*1, 3-1j*1, -1-1j, -3-1j*1, 1-1j*3, 3-1j*3, -1-1j*3, -3-1j*3, 1+1j*1, 3+1j*1, -1+1j,-3+1j*1, 1+1j*3, 3+1j*3, -1+1j*3, -3+1j*3]'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      RAW8PACKED: I0 I1 Q0 Q1  I0' I1' Q0' Q1'
      2-bit sign-magnitude
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1+1j*1, 3+1j*1, -1+1j, -3+1j*1, 1+1j*3, 3+1j*3, -1+1j*3, -3+1j*3, 1-1j*1, 3-1j*1, -1-1j,-3-1j*1, 1-1j*3, 3-1j*3, -1-1j*3, -3-1j*3]'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.1.63:5555
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_interleaved_char_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_interleaved_char_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_complex_to_interleaved_char_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_deinterleave_0, '0', blocks_complex_to_interleaved_char_0_0, '0']
- [blocks_deinterleave_0, '1', blocks_complex_to_interleaved_char_0, '0']
- [blocks_deinterleave_0_0, '0', blocks_complex_to_interleaved_char_0_0_0, '0']
- [blocks_deinterleave_0_0, '1', blocks_complex_to_interleaved_char_0_1, '0']
- [blocks_head_0, '0', blocks_deinterleave_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_head_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_deinterleave_0_0, '0']
- [zeromq_sub_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
