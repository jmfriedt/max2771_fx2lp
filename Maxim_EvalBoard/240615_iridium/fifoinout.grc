options:
  parameters:
    generate_options: qt_gui
    id: fifo_acq
    output_language: python
    title: FIFO acquisition
  states: {}

blocks:
- name: IF
  id: variable
  parameters:
    value: 5.96e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 24e6
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: IF
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e5
    win: window.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '127'
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/iridium.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: mkfifo /tmp/fifo
    file: /tmp/fifo
    repeat: 'True'
    type: byte
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: IF
    decim: '2'
    samp_rate: samp_rate
    taps: taps
    type: fcc
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    comment: |-
      sudo pocket_conf  pocket_iridium_24MHz.conf 
      sudo pocket_dump -r - > /tmp/fifo
    fc: '0'
    fftsize: '16384'
    name: '"spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5005
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
