options:
  parameters:
    generate_options: no_gui
    id: MAX2771_transpose
    output_language: python
    title: MAX2771_transpose
  states: {}

blocks:
- name: filtre
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 2e6
    gain: '1.0'
    samp_rate: samp_rate
    width: 2.2e6
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '127'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/fifo1in
    repeat: 'False'
    type: byte
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2e6
    decim: '4'
    samp_rate: samp_rate
    taps: filtre
    type: fcc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://lo:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
